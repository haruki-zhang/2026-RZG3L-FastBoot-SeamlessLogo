# Extends the display driver of meta-rzg3l-seamless-logo-still.
# fla_mailbox.h comes from the CM33 firmware sources, so both sides are built
# from the same interface definition.
#
# ":append" is applied after the still logo layer's "+=", so 0001 applies on
# top of its patches. meta-rzg3l-lp-display-demo also patches this driver, but
# other lines, so that order does not matter.
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:${FLA_FW_FILESDIR}:"

SRC_URI:append:smarc-rzg3l = " \
    file://0001-video-rzg2l-hand-Layer1-over-to-the-CM33-fast-logo-an.patch \
    file://fla-uboot \
    file://fla-anim/fla_mailbox.h \
"

# FLA_TEST_PATTERN is for bring-up only:
#   ""      the animation from /boot/fla_anim.bin.gz
#   still   one opaque 256x256 frame, no animation file needed
#   sync    a white / black column switched every FLA_PERIOD_MS, to check that
#           frame switches never tear
FLA_TEST_PATTERN ?= ""
FLA_PERIOD_MS ?= "10"
FLA_TIMEOUT_MS ?= "60000"

# ":=" because THISDIR points to the recipe, not to this layer, when a task
# runs. The error messages below must name this layer.
FLA_UBOOT_DIR := "${THISDIR}"

python () {
    import re
    if (d.getVar('FLA_TEST_PATTERN') or '') not in ('', 'still', 'sync'):
        bb.fatal("FLA_TEST_PATTERN is '%s'; expected \"\" (the animation), still or sync."
                 % d.getVar('FLA_TEST_PATTERN'))
    if not re.fullmatch(r'[1-9][0-9]*x[1-9][0-9]*', d.getVar('FLA_ANIM_SIZE') or ''):
        bb.fatal("FLA_ANIM_SIZE is '%s'; expected <width>x<height>." % d.getVar('FLA_ANIM_SIZE'))
    y = d.getVar('FLA_ANIM_Y') or ''
    if not y.isdigit() or int(y) > 1000:
        bb.fatal("FLA_ANIM_Y is '%s'; expected 0..1000 (per mille of the screen height)." % y)
    for v in ('FLA_PERIOD_MS', 'FLA_TIMEOUT_MS'):
        if not (d.getVar(v) or '').isdigit():
            bb.fatal("%s is '%s'; expected a number of milliseconds." % (v, d.getVar(v)))
}

do_configure:prepend:smarc-rzg3l() {
    d="${S}/drivers/video/rzg2l"

    if ! grep -q 'rzg2l_fla_setup(dl_headers\[0\], dl_headers\[1\]' "$d/rzg2l_video.c"; then
        bbfatal "rzg2l_vcpd_dl_init() does not call rzg2l_fla_setup(). Re-check 0001-*.patch in ${FLA_UBOOT_DIR} against the display driver of meta-rzg3l-seamless-logo-still."
    fi
    if ! grep -q '^	rzg2l_fla_start();' "$d/rzg2l_video.c"; then
        bbfatal "rzg2l_video_init() does not call rzg2l_fla_start(). Re-check 0001-*.patch in ${FLA_UBOOT_DIR} against the display driver of meta-rzg3l-seamless-logo-still."
    fi
    install -m 0644 ${WORKDIR}/fla-uboot/rzg2l_fla.c ${WORKDIR}/fla-uboot/rzg2l_fla.h \
        ${WORKDIR}/fla-anim/fla_mailbox.h "$d/"

    case "${FLA_TEST_PATTERN}" in
    still) pattern=FLA_PATTERN_STILL ;;
    sync)  pattern=FLA_PATTERN_SYNC ;;
    *)     pattern=FLA_PATTERN_ANIM ;;
    esac
    size="${FLA_ANIM_SIZE}"
    cat > "$d/fla_config.h" <<EOF
/* Generated by meta-rzg3l-seamless-logo-cm33-anim recipes-bsp/u-boot */
#define FLA_CFG_PATTERN		$pattern	/* FLA_TEST_PATTERN = "${FLA_TEST_PATTERN}" */
#define FLA_CFG_ANIM_W		${size%x*}	/* FLA_ANIM_SIZE = ${FLA_ANIM_SIZE} */
#define FLA_CFG_ANIM_H		${size#*x}
#define FLA_CFG_ANIM_Y_PERMILLE	${FLA_ANIM_Y}	/* FLA_ANIM_Y: vertical centre */
#define FLA_CFG_PERIOD_MS	${FLA_PERIOD_MS}	/* sync */
#define FLA_CFG_TIMEOUT_MS	${FLA_TIMEOUT_MS}
EOF
}
